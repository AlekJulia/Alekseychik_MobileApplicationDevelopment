# Keil uVision project ds18b20_CMSIS.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ds18b20_CMSIS
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c ds18b20.h ds18b20.c sensor_monitor.c sensor_monitor.h uart_driver.c uart_driver.h ClockConfigureHSE.c ClockConfigureHSE.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
